# IAR project LossPhase_Uart_st8s.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\Lib\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LossPhase_Uart_st8s.srec
  ILINK.IlinkOutputFile: LossPhase_Uart_st8s.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    ../Lib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_uart1.c
  group User
    ../User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
