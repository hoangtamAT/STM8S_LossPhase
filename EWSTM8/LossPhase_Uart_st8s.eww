<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LossPhase_Uart_st8s.ewp</path>
  </project>
  <batchBuild/>
</workspace>


